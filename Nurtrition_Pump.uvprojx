# Keil uVision project Nurtrition_Pump.uvprojx, settings and files
target 加温 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: AT32F415CBT7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.5
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: Nurtrition_Pump +hex
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F415CBT7,USE_STDPERIPH_DRIVER,AT_START_F415_V1
  c include: .\USER\inc;.\BSP\inc;.\CMSIS;.\CMSIS\coresupport;.\HARDWARE\inc;.\LOGIC\inc;.\SYSTEM\inc;.\USER
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group USER
    ./USER/src/: at32f415_clock.c at32f415_int.c main.c
    ./USER/: hardware_config.h threshold_config.h
  group BSP
    ./BSP/src/: at32f415_adc.c at32f415_can.c at32f415_cmp.c at32f415_crc.c at32f415_crm.c at32f415_debug.c at32f415_dma.c at32f415_ertc.c at32f415_exint.c at32f415_flash.c at32f415_gpio.c at32f415_i2c.c at32f415_misc.c at32f415_pwc.c at32f415_sdio.c at32f415_spi.c at32f415_tmr.c at32f415_usart.c at32f415_usb.c at32f415_wdt.c at32f415_wwdt.c
  group HARDWARE
    ./HARDWARE/src/: motor.c clip.c bubble.c press.c key.c led.c
  group LOGIC
    ./LOGIC/src/: l_clip.c
  group CMSIS
    ./CMSIS/: system_at32f415.c startup_at32f415.s
  group SYSTEM
    ./SYSTEM/src/: delay.c adc.c usart.c timer.c exti.c eeprom.c
